# Repository NicholasAntoniadesEngineer/Signal-Generator

File README.md:

# Waveform generator
 Waveform generator using STM32F4

## KiCad design PCB/Waveform Generator/Waveform Generator.kicad_pcb

Parts:
3V3, 5V1: 5001; 5001 Test Point
BTN0: RESET Button; TS-1109S-B-B
BTN1: Btn1; TS-1109S-B-B
BTN2: Btn2; TS-1109S-B-B
BTN3: BTN3; TS-1109S-B-B
C1, C2: 10n; C_1206_3216Metric
C3, C4, C5, C6: 10n; C_0603_1608Metric
C7, C10: 10u; C_0603_1608Metric
C8, C9: 0.1u; C_0603_1608Metric
C11, C12, C13, C24: 12p; C_0402_1005Metric
C14: 4u7; C_0402_1005Metric
C15, C16, C17, C18, C19, C31: 100n; C_0402_1005Metric
C20, C21: 1u; C_0402_1005Metric
C22, C23: 2.2u; C_0402_1005Metric
C25, C26: 20p; C_0402_1005Metric
C27, C28, C29, C30: 10u; C_0402_1005Metric
D1: B5819W; D_SOD-123
D4: BLUE; LED_0603_1608Metric
DAC_OUT_1, DAC_OUT_2: 5001; 5001 Test Point
F1: 300mA; Fuse_0603_1608Metric
FB1, FB2: 100 @ 100MHz; L_1206_3216Metric
GND1: 5001; 5001 Test Point
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_Pad_Via
J1: Power input; 5mm Pitch, 2 Way Terminal Block
J2: RS485_1; 5mm Pitch, 2 Way Terminal Block
J3: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J5: Signal 1; 5mm Pitch, 2 Way Terminal Block
J6: SWD; PinSocket_2x05_P1.27mm_Vertical
J7: RS485_2; 5mm Pitch, 2 Way Terminal Block
J8: USART1_1; 5mm Pitch, 2 Way Terminal Block
J9: ADC_1; 5mm Pitch, 2 Way Terminal Block
J10: USART1_2; 5mm Pitch, 2 Way Terminal Block
J12: Signal 2; 5mm Pitch, 2 Way Terminal Block
J19: ADC_2; 5mm Pitch, 2 Way Terminal Block
J20: TIMER_1; 5mm Pitch, 2 Way Terminal Block
J21: I2C1_1; 5mm Pitch, 2 Way Terminal Block
J22: TIMER_2; 5mm Pitch, 2 Way Terminal Block
J23: I2C1_2; 5mm Pitch, 2 Way Terminal Block
LED1: BLUE; LED_0603_1608Metric
LED2, LED4: RED; LED_0603_1608Metric
LED3, LED5: GREEN; LED_0603_1608Metric
PS1: ITP0324D05; ITP0312D05
PS2: AMS1117-3.3; SOT-223-3_TabPin2
PWR1, PWR2, PWR3: GREEN; LED_0603_1608Metric
Q0: AO3401A; SOT-23
Q2, Q4, Q5, Q6, Q7, Q8: Q_NPN_BCE; SOT-23
Q3: Q_PNP_BCE; SOT-23
R1, R2, R3, R4, R7, R11, R15, R16, R17, R18: 1k; R_0402_1005Metric
R5, R13, R14, R19, R20: 10k; R_0402_1005Metric
R6, R8, R35, R36: 1k; R_0603_1608Metric
R9: 47; R_0603_1608Metric
R12: 47; R_0402_1005Metric
R21, R22, R24, R26, R28: 470; R_0603_1608Metric
R23, R25, R27, R37, R38: 33; R_0402_1005Metric
R29, R30, R31, R32: 22; R_0402_1005Metric
R33, R34: 2k2; R_0402_1005Metric
R39: 120; R_0603_1608Metric
RS485_A1, RS485_B1: 5001; 5001 Test Point
SW1, SW2, SW3: SW_SPDT; SW_SPDT_PCM12
TEMP_SENSE1: 5001; 5001 Test Point
U1: STM32F429VGT6; LQFP-100_14x14mm_P0.5mm
U2: MAX485EESAT; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U3, U6, U7, U9, U10, U11: USBLC6-2SC6; SOT-23-6
U4, U5: OPA1602; SOP-8_3.9x4.9mm_P1.27mm
U8: LM335ADT; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
X1: 25MHZ; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: C20.1, C21.2, FB2.2, U1.21 (VREF+), U1.22 (VDDA)
+3V3: C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, FB2.1, J6.1, J8.1, J9.1, J20.1, J21.1, PWR3.2 (A), R21.1, R22.1, R24.1, R26.1, R28.1, R33.2, R34.2, SW1.1 (A), SW2.1 (A), SW3.1 (A), U1.6 (VBAT), U1.11 (VDD), U1.19 (VDD), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD)
+5V: 5V1.1, C7.1, C8.1, FB1.2, J2.1, PS2.3 (VI), Q3.3 (E), R8.1, U4.8 (V+), U5.8 (V+), U6.5 (VBUS), U7.5 (VBUS), U8.8, U9.5 (VBUS), U10.5 (VBUS), U11.5 (VBUS)
-5V: C5.2, C6.2, PS1.6, U4.4 (V-), U5.4 (V-)
ADC1_IN1: U1.24 (PA1), U7.1 (IO1)
ADC2_IN0: U1.23 (PA0), U7.3 (IO2)
BOOT0: R13.2, U1.94 (BOOT0)
BOOT1: R5.2, U1.37 (PB2)
BTN1_Input: BTN1.1, C11.2, U1.65 (PC8)
BTN2_Input: BTN2.1, C12.2, U1.64 (PC7)
BTN3_Input: BTN3.1, C13.2, U1.63 (PC6)
DAC_OUT1: R15.2, U1.29 (PA4)
DAC_OUT2: R2.2, U1.30 (PA5)
GND: BTN0.2, BTN1.2, BTN2.2, BTN3.2, C1.2, C2.1, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.1, C25.1, C26.1, C31.2, GND1.1, H1.1, H2.1, H3.1, H4.1, J1.1, J3.5 (GND), J5.2, J7.2, J10.2, J12.2, J19.2, J22.2, J23.2, PS1.1, PS1.5, Q0.1 (G), Q2.3 (E), Q4.3 (E), Q5.3 (E), Q6.3 (E), Q7.3 (E), Q8.3 (E), R6.2, R14.2, R19.2, R20.2, R35.2, R36.2, SW2.3 (C), SW3.3 (C), U1.10 (VSS), U1.20 (VSSA), U1.27 (VSS), U1.74 (VSS), U1.99 (VSS), U2.5 (GND), U3.2 (GND), U4.3 (+), U4.5 (+), U5.3 (+), U5.5 (+), U6.2 (GND), U7.2 (GND), U8.4, U9.2 (GND), U10.2 (GND), U11.2 (GND), X1.2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
HSE_IN: C25.2, U1.12 (PH0), X1.1
HSE_OUT: R12.1, U1.13 (PH1)
I2C1_SCL: U1.92 (PB6), U11.3 (IO2)
I2C1_SDA: U1.96 (PB9), U11.1 (IO1)
LED1: R27.2, U1.58 (PD11)
LED2: R25.2, U1.59 (PD12)
LED3: R23.2, U1.60 (PD13)
LED4: R38.2, U1.61 (PD14)
LED5: R37.2, U1.62 (PD15)
MAX485_PWR: R7.2, U1.15 (PC0)
NRST: BTN0.1, C24.2, C31.1, R32.1, U1.14 (NRST)
unnamed: 3V3.1, C9.1, C10.1, PS2.2 (VO), PWR2.2 (A), SW1.2 (B)
unnamed: C1.1, C2.2, PS1.2, Q0.2 (S)
unnamed: C3.1, C4.1, D1.1 (K), F1.2, PS1.4, PWR1.2 (A)
unnamed: C22.1, U1.49 (VCAP_1)
unnamed: C23.1, U1.73 (VCAP_2)
unnamed: C26.2, R12.2, X1.3
unnamed: C27.1, R15.1
unnamed: C27.2, R16.1, U4.2 (-)
unnamed: C28.1, R17.1
unnamed: C28.2, R18.2, U4.6 (-)
unnamed: C29.1, R1.1
unnamed: C29.2, R3.2, U5.6 (-)
unnamed: C30.1, R2.1
unnamed: C30.2, R4.1, U5.2 (-)
unnamed: D4.1 (K), U2.8 (VCC)
unnamed: D4.2 (A), R9.2
unnamed: DAC_OUT_1.1, R18.1, U4.7, U9.3 (IO2)
unnamed: DAC_OUT_2.1, R3.1, U5.7, U9.1 (IO1)
unnamed: F1.1, FB1.1
unnamed: J2.2, R39.1, RS485_B1.1, U2.7 (B)
unnamed: J3.2 (D-), U3.4 (IO2)
unnamed: J3.3 (D+), U3.6 (IO1)
unnamed: J5.1, U9.6 (IO1)
unnamed: J6.2, R29.2
unnamed: J6.3, R14.1
unnamed: J6.4, R30.2
unnamed: J6.5, R19.1
unnamed: J6.6, R31.2
unnamed: J6.9, R20.1
unnamed: J6.10, R32.2
unnamed: J7.1, R39.2, RS485_A1.1, U2.6 (A)
unnamed: J8.2, U6.6 (IO1)
unnamed: J9.2, U7.6 (IO1)
unnamed: J10.1, U6.4 (IO2)
unnamed: J12.1, U9.4 (IO2)
unnamed: J19.1, U7.4 (IO2)
unnamed: J20.2, U10.6 (IO1)
unnamed: J21.2, R34.1, U11.6 (IO1)
unnamed: J22.1, U10.4 (IO2)
unnamed: J23.1, R33.1, U11.4 (IO2)
unnamed: LED1.1 (K), Q6.2 (C)
unnamed: LED1.2 (A), R28.2
unnamed: LED2.1 (K), Q5.2 (C)
unnamed: LED2.2 (A), R26.2
unnamed: LED3.1 (K), Q4.2 (C)
unnamed: LED3.2 (A), R24.2
unnamed: LED4.1 (K), Q8.2 (C)
unnamed: LED4.2 (A), R22.2
unnamed: LED5.1 (K), Q7.2 (C)
unnamed: LED5.2 (A), R21.2
unnamed: PWR1.1 (K), R36.1
unnamed: PWR2.1 (K), R6.1
unnamed: PWR3.1 (K), R35.1
unnamed: Q2.1 (B), R7.1
unnamed: Q2.2 (C), Q3.1 (B), R8.2
unnamed: Q3.2 (C), R9.1
unnamed: Q4.1 (B), R23.1
unnamed: Q5.1 (B), R25.1
unnamed: Q6.1 (B), R27.1
unnamed: Q7.1 (B), R37.1
unnamed: Q8.1 (B), R38.1
unnamed: R1.2, R4.2, U5.1
unnamed: R5.1, SW2.2 (B)
unnamed: R11.1, U2.2 (~RE), U2.3 (DE)
unnamed: R13.1, SW3.2 (B)
unnamed: R16.2, R17.2, U4.1
SW0: R31.1, U1.89 (PB3)
SWCLK: R30.1, U1.76 (PA14)
SWDIO: R29.1, U1.72 (PA13)
TEMP_SENSE: TEMP_SENSE1.1, U1.17 (PC2), U8.5
TIM1_CH1: U1.40 (PE9), U10.1 (IO1)
TIM3_CH1: U1.31 (PA6), U10.3 (IO2)
USART1_RX: U1.93 (PB7), U6.3 (IO2)
USART1_TX: U1.68 (PA9), U6.1 (IO1)
USART2_RTS: R11.2, U1.85 (PD4)
USART2_RX: U1.26 (PA3), U2.1 (RO)
USART2_TX: U1.25 (PA2), U2.4 (DI)
USB_D+: U1.71 (PA12), U3.1 (IO1)
USB_D-: U1.70 (PA11), U3.3 (IO2)
USB_ID: J3.4 (ID), U1.69 (PA10)
VBUS: D1.2 (A), J3.1 (VBUS), U3.5 (VBUS)
VCC: J1.2, Q0.3 (D)

Notes on the sheet:
5v to 3v3
Pwr LED and Switch
HSE Crystal
Boot Switches
Reset
MCU
Decoupling
Connectors
Buttons
SWD
Mounting Holes
24v to +-5v regulator
RS485
LEDs
Level Shifting to Signal Output
USB
Power Circuitry
TEMP SENSE

Board: 4 copper layers, 80.0 x 105.2 mm, 138 parts (0 on the bottom side), 107 nets.

File PCB/Waveform Generator/assembly/Waveform Generator-BOM.csv:

Designator;Quantity;Value;Footprint;LCSC Part#
BTN0, ;1;RESET Button;SMD;C480315
BTN1, ;1;Btn1;SMD;C480315
BTN2, ;1;Btn2;SMD;C480315
BTN3, ;1;BTN3;SMD;C480315
C1, C2, ;2;10n;1206;C1846
C3, C4, C5, C6, ;4;10n;603;C57112
C7, C10, ;2;10u;603;C19702
C8, C9, ;2;0.1u;603;C14663
C11, C12, C13, C24, ;4;12p;402;C1547
C14, ;1;4u7;402;C23733
C15, C16, C17, C18, C19, C31, ;6;100n;402;C1525
C20, C21, ;2;1u;402;C52923
C22, C23, ;2;2.2u;402;C12530
C25, C26, ;2;20p;402;C1554
C27, C28, C29, C30, ;4;10u;402;C15525
D1, ;1;B5819W;SOD-123;C8598
D4, D11, LED1, ;3;BLUE;603;C72041
F1, ;1;300mA;603;C207010
FB1, FB2, ;2;100 @ 100MHz;1206;C1023
J3;1;USB_B_MICRO;USB-5.6X7.59;C145792
J6;1;SWD;HDR-TH_10P-P2.54-V-M-R2-C5-S2.54;C124387
LED2, LED4, ;2;RED;603;C2286
LED3, LED5, PWR1, PWR2, PWR3, ;5;GREEN;603;C72043
PS2, ;1;AMS1117-3.3;SOT-223;C6186
Q0, ;1;AO3401A;SOT-23;C15127
Q1, Q2, Q4, Q5, Q6, Q7, Q8, ;7;Q_NPN_BCE;SOT-23;C2150
Q3, ;1;Q_PNP_BCE;SOT-23;C8542
R1, R2, R3, R4, R7, R11, R15, R16, R17, R18, ;10;1k;402;C11702
R5, R13, R14, R19, R20, ;5;10k;402;C25744
R6, R8, R35, R36, ;4;1k;603;C21190
R9;1;47;603;C23182
R10, R21, R22, R24, R26, R28, ;6;470;603;C23179
R12;1;47;402;C25118
R23, R25, R27, R37, R38, ;5;33;402;C25105
R29, R30, R31, R32, ;4;22;402;C25092
R33, R34, ;2;2k2;402;C25879
R39;1;120;603;C22787
SW1, SW2, SW3, ;3;SW_SPDT;SMD;C319019
U1, ;1;STM32F427VITx;LQFP-100_14.0x14.0x0.5P;C57097
U2, ;1;MAX485EESAT;SOIC-8_3.9x4.9x1.27P;C23492
U3, U6, U7, U9, U10, U11, ;6;USBLC6-2SC6;SOT-23-6;C7519
U4, U5, ;2;OPA1602;SOP-8_3.9x4.9x1.27P;C70884
U8, ;1;LM335ADT;SOIC-8_3.9x4.9x1.27P;C361027
X1, ;1;25MHZ;SMD-3225_4P;C9006

## KiCad design PCB/Reference/Renard/KiCad/Amp_Relay/Amp_Relay-LAPTOP-HUDS25TS.kicad_pcb

Schematic: Amp_Relay-LAPTOP-HUDS25TS.sch, Nanodyn Amplifier Interface PCB

Parts:
C1, C5, C6, C15, C17, C23, C26, C29, C31, C32, C33, C36, C37, C38, C39, C42, C43, C46: 1u; 0805
C2, C13, C14, C16, C18, C27, C28, C30, C34, C35, C40, C41, C44, C45, C47: 100n; 0805
C3, C4, C7, C10, C11, C12, C19, C22, C24, C25: 100p; 0805
C8, C9, C20, C21: C0805; 0805
CB1: 2905067
D1, D2, D3: MBRS360T3G
F1, F2: 65600001009
J1, J6, J7, J8, J9, J18, J19, J20, J21, J30, J31: Tab_L
J2, J3, J4, J5, J10, J11, J12, J13, J14, J15, J16, J17, J22, J23, J24, J25, J26, J27, J28, J29, J32, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42, J43, J44, J45: Tab_S
K1: 66.22.9.024.0600
K2, K3: FTR-F3AA024E-HA
L1, L2: L0805; 0805
MH1, MH2, MH3, MH4, MH5, MH6: Hole_M3; Mounting_Hole_M3
PS1: TML_40112; TML 40112
PS2: ISP1205
R1, R3, R4, R6: 500k; 0805
R2, R5, R7, R8, R11, R12, R13, R14, R15, R16, R17, R18, R21, R22, R23, R24, R25, R27, R28, R29, R33, R34, R35, R37, R38, R41: 10k; 0805
R9, R10, R19, R20: 1k; 0805
R26: 38k; 0805
R30, R31, R32: 0; 0805
R36, R39, R40: 20k; 0805
TC1: LM35DT
U1, U2, U3, U4: LTC2051HVIMS8#PBF
Z1, Z2, Z3, Z4: LM4050CIM3-2.5_NOPB

Connections:
+5V: C5.1, C13.1, C17.1, C18.1, C29.1, C30.1, C32.1, C34.1, C38.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, J38.1, J40.1, L1.2, R9.1, R10.1, R19.1, R20.1, TC1.1, U1.8, U2.8, U3.8, U4.8
+12V: F1.1, J8.1, PS1.4 (DC+)
-5V: C6.2, C14.2, C15.1, C16.1, C26.1, C28.1, C33.1, C35.1, C37.1, C40.1, L2.2, U1.4, U2.4, U3.4, U4.4
/PLC_Power_ON_24V: CB1.3, D3.2, J10.1, K1.1
Earth: J1.1, MH1.1, MH2.1, MH3.1, MH4.1, MH5.1, MH6.1, R30.1, R31.1, R32.1
GND: C1.2, C2.2, J9.1, PS1.3 (DC-), PS2.2, R30.2
GNDA: C5.2, C6.1, C8.2, C9.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C26.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, J39.1, J41.1, J45.1, PS2.4, R31.2, R33.1, R37.1, R41.2, TC1.2, Z1.2, Z2.2, Z3.2, Z4.2
GNDD: C23.2, C27.2, D1.1, D2.1, D3.1, J11.1, J13.1, J15.1, J33.1, K1.2, K2.2, K3.2, R23.2, R27.2, R32.2
unnamed: C1.1, C2.1, F1.2, PS2.1
unnamed: C3.1, R1.2, R2.1, R7.1
unnamed: C3.2, R2.2, R3.1, R8.1
unnamed: C4.1, R5.1, R6.2, R12.1
unnamed: C4.2, R4.1, R5.2, R11.1
unnamed: C7.1, R8.2, R13.1, U1.3
unnamed: C7.2, C8.1, R9.2, R13.2, Z1.1
unnamed: C10.1, R11.2, R14.1, U1.5
unnamed: C9.1, C10.2, R10.2, R14.2, Z2.1
unnamed: C11.1, R7.2, R15.1, U1.2
unnamed: C11.2, J16.1, R15.2, U1.1
unnamed: C12.1, R12.2, R16.1, U1.6
unnamed: C12.2, J17.1, R16.2, U1.7
unnamed: C19.1, R18.2, R24.1, U2.3
unnamed: C19.2, C20.1, R19.2, R24.2, Z3.1
unnamed: C21.1, C22.2, R20.2, R25.2, Z4.1
unnamed: C22.1, R21.2, R25.1, U2.5
unnamed: C23.1, C27.1, J32.1, R26.2, R27.1
unnamed: C24.1, R17.2, R28.1, U2.2
unnamed: C24.2, J36.1, R28.2, U2.1
unnamed: C25.1, R22.2, R29.1, U2.6
unnamed: C25.2, J37.1, R29.2, U2.7
unnamed: C31.1, R34.2, U3.3
unnamed: C36.1, R38.2, U4.3
unnamed: C39.1, R35.2, U3.5
unnamed: CB1.1, J31.1
unnamed: CB1.2, R23.1
unnamed: CB1.4, R26.1
unnamed: CB1.5, J30.1
unnamed: D1.2, J12.1, K2.1
unnamed: D2.2, J14.1, K3.1
unnamed: F2.1, J6.1
unnamed: F2.2, PS1.1 (AC_L)
unnamed: J2.1, R1.1
unnamed: J3.1, R3.2
unnamed: J4.1, R4.2
unnamed: J5.1, R6.1
unnamed: J7.1, PS1.2 (AC_N)
unnamed: J18.1, K1.6
unnamed: J19.1, K1.5
unnamed: J20.1, K1.4
unnamed: J21.1, K1.3
unnamed: J22.1, K2.4
unnamed: J23.1, K2.3
unnamed: J24.1, K3.4
unnamed: J25.1, K3.3
unnamed: J26.1, R17.1
unnamed: J27.1, R18.1
unnamed: J28.1, R21.1
unnamed: J29.1, R22.1
unnamed: J34.1, R34.1
unnamed: J35.1, R35.1
unnamed: J42.1, R39.2, U4.1
unnamed: J43.1, R36.2, U3.1
unnamed: J44.1, R40.1, U3.7
unnamed: L1.1, PS2.5
unnamed: L2.1, PS2.3
unnamed: R33.2, R36.1, U3.2
unnamed: R37.2, R39.1, U4.2
unnamed: R38.1, TC1.3
unnamed: R40.2, R41.1, U3.6

Notes on the sheet:
CH2_VOLTAGE_IN
CH1_VOLTAGE_IN
CH1_VOLTAGE_OUT
CH2_VOLTAGE_OUT
CH2_CURRENT_IN
CH1_CURRENT_IN
CH2_CURRENT_OUT
CH1_CURRENT_OUT
Power Supplies
Switching Relays And Breaker
Voltage Measurement Circuits
Current Measurement Circuits
Earthing and Referencing
CH1_Temp_In
CH2_Temp_In
Ch1_Out
Ch2_Out
Ch2_Temp_Pwr+
Ch2_Temp_Pwr-
Amb_Temp_Out
Temperature Measurement Circuits
Ambient Temperature Sensor
Ch1_Temp_Pwr-
Ch1_Temp_Pwr+
M3 Mounting Holes

Board: 4 copper layers, 263.0 x 77.0 mm, 161 parts (0 on the bottom side), 69 nets.

## KiCad design PCB/Reference/Renard/KiCad/Amp_Hall_Effect_Sensor/Amp_Hall_Effect_Sensor.kicad_pcb

Parts:
C1, C3: 1u; C0805
C2, C4: Clfp; C0805
C5, C6: 100n; C0805
J1, J2, J3, J4, J5, J6, J7: Tab_S
MH1, MH2, MH3, MH8: Hole_M2.5
MH4, MH5, MH6, MH7: Hole_M2
R1: 0; R0805
R2, R3: Rlpf; R0805
U1, U2: ACS758LCB-050B-PFF-T

Connections:
+5V: C1.1, C3.1, C5.1, C6.1, J1.1, J4.1, U1.1, U2.1
Earth: J7.1, MH1.1, MH2.1, MH3.1, MH8.1, R1.1
GNDA: C1.2, C2.1, C3.2, C4.1, C5.2, C6.2, J2.1, J5.1, R1.2, U1.2, U2.2
unnamed: C2.2, J3.1, R2.1
unnamed: C4.2, J6.1, R3.1
unnamed: MH4.1, U1.5
unnamed: MH5.1, U1.4
unnamed: MH6.1, U2.5
unnamed: MH7.1, U2.4
unnamed: R2.2, U1.3
unnamed: R3.2, U2.3

Notes on the sheet:
+5V
GND
Ch1 Iout
Ch2 Iout
Ch1+ Current
Ch1- Current
Ch2- Current
Ch2+ Current
Earth
Hall Effect Current Measurement Circuits

Board: 2 copper layers, 69.0 x 45.0 mm, 26 parts (0 on the bottom side), 11 nets.

File PCB/Reference/Renard/KiCad/Amp_Hall_Effect_Sensor/BOM_Hall_Effect_Sensor.xlsx:

| AMP INTERFACE BOARD BOM |  |  |  | AMP INTERFACE BOARD COMPONENT PLACEMENT
 | DESCRIPTION | COMPONENT | QTY |  | ref | value5 | footprint | datasheet | lib | part | description
 | SENSOR |  |  |  | U1 | ACS758LCB-050B-PFF-T | Amp_Hall_Effect_Sensor:ACS758LCB-050B-PFF-T | https://docs.rs-online.com/a0f2/0900766b80d885f6.pdf | Amp_Hall_Effect_Sensor | ACS758LCB-050B-PFF-T | Hall Effect Sensor Current Measurement
 | Hall Effect-Based Linear Current Sensor IC | ACS758LCB-050B-PFF-T | 2 |  | C1 | 1u | Amp_Hall_Effect_Sensor:C0805 |  | Amp_Hall_Effect_Sensor | C0805 | Ceramic Capacitor 0805
 | CAPACITORS |  |  |  | R2 | Rlpf | Amp_Hall_Effect_Sensor:R0805 |  | Amp_Hall_Effect_Sensor | R0805 | Resistor 0805
 | Capacitor 0805 package | 1u | 2 |  | C5 | 100n | Amp_Hall_Effect_Sensor:C0805 |  | Amp_Hall_Effect_Sensor | C0805 | Ceramic Capacitor 0805
 | Capacitor 0805 package | 100n | 2 |  | C2 | Clfp | Amp_Hall_Effect_Sensor:C0805 |  | Amp_Hall_Effect_Sensor | C0805 | Ceramic Capacitor 0805
 | Capacitor 0805 package | Clfp | 2 |  | J1 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 | Resistor 0805 package | Rlpf | 2 |  | J2 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 | CONNECTORS |  |  |  | J3 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 | 2.79 x 0.5mm Tab Size | Tab_S | 7 |  | MH4 | Hole_M2 | Amp_Hall_Effect_Sensor:Hole_M2 |  | Amp_Hall_Effect_Sensor | Hole_M2 | Mounting Hole M2
 |  |  |  |  | MH5 | Hole_M2 | Amp_Hall_Effect_Sensor:Hole_M2 |  | Amp_Hall_Effect_Sensor | Hole_M2 | Mounting Hole M2
 |  |  |  |  | U2 | ACS758LCB-050B-PFF-T | Amp_Hall_Effect_Sensor:ACS758LCB-050B-PFF-T | https://docs.rs-online.com/a0f2/0900766b80d885f6.pdf | Amp_Hall_Effect_Sensor | ACS758LCB-050B-PFF-T | Hall Effect Sensor Current Measurement
 |  |  |  |  | C3 | 1u | Amp_Hall_Effect_Sensor:C0805 |  | Amp_Hall_Effect_Sensor | C0805 | Ceramic Capacitor 0805
 |  |  |  |  | R3 | Rlpf | Amp_Hall_Effect_Sensor:R0805 |  | Amp_Hall_Effect_Sensor | R0805 | Resistor 0805
 |  |  |  |  | C6 | 100n | Amp_Hall_Effect_Sensor:C0805 |  | Amp_Hall_Effect_Sensor | C0805 | Ceramic Capacitor 0805
 |  |  |  |  | C4 | Clfp | Amp_Hall_Effect_Sensor:C0805 |  | Amp_Hall_Effect_Sensor | C0805 | Ceramic Capacitor 0805
 |  |  |  |  | J4 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 |  |  |  |  | J5 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 |  |  |  |  | J6 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 |  |  |  |  | MH6 | Hole_M2 | Amp_Hall_Effect_Sensor:Hole_M2 |  | Amp_Hall_Effect_Sensor | Hole_M2 | Mounting Hole M2
 |  |  |  |  | MH7 | Hole_M2 | Amp_Hall_Effect_Sensor:Hole_M2 |  | Amp_Hall_Effect_Sensor | Hole_M2 | Mounting Hole M2
 |  |  |  |  | MH1 | Hole_M2.5 | Amp_Hall_Effect_Sensor:Hole_M2.5 |  | Amp_Hall_Effect_Sensor | Hole_M2.5 | Mounting Hole M2.5
 |  |  |  |  | MH2 | Hole_M2.5 | Amp_Hall_Effect_Sensor:Hole_M2.5 |  | Amp_Hall_Effect_Sensor | Hole_M2.5 | Mounting Hole M2.5
 |  |  |  |  | MH3 | Hole_M2.5 | Amp_Hall_Effect_Sensor:Hole_M2.5 |  | Amp_Hall_Effect_Sensor | Hole_M2.5 | Mounting Hole M2.5
 |  |  |  |  | MH8 | Hole_M2.5 | Amp_Hall_Effect_Sensor:Hole_M2.5 |  | Amp_Hall_Effect_Sensor | Hole_M2.5 | Mounting Hole M2.5
 |  |  |  |  | J7 | Tab_S | Amp_Hall_Effect_Sensor:Tab_S | https://za.rs-online.com/web/p/solder-tab-terminals/1177246/ | Amp_Hall_Effect_Sensor | Tab_S | Small Tab Connector
 |  |  |  |  | R1 | 0 | Amp_Hall_Effect_Sensor:R0805 |  | Amp_Hall_Effect_Sensor | R0805 | Resistor 0805
