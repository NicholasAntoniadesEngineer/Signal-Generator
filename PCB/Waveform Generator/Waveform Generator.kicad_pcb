# Repository NicholasAntoniadesEngineer/Signal-Generator (continued)

## KiCad design PCB/Reference/Renard/KiCad/Amp_Input_Filter/Amp_Input_Filter.kicad_pcb

Parts:
C1, C7, C15, C19, C23, C27, C31, C35, C39, C43: 15uF; 0805
C2, C4, C8, C9, C14, C16, C22, C24, C30, C32, C38, C40, C46: 1uF; 0805
C3, C6, C10, C11, C13, C18, C21, C26, C29, C34, C37, C42, C45: 100nF; 0805
C5, C12, C17, C20, C25, C28, C33, C36, C41, C44: 3.3nF; 0805
F1: 65600001009
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15: Tab_S
L1, L2: 47 uH; 0805
MH1, MH2, MH3, MH4: Hole_M3; Mounting_Hole_M3
PS1: ISP2405
R1, R3: 0; 0805
R2, R4, R5, R6, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24: 1k; 0805
R7, R8: x; 0805
U1, U2, U3, U4, U5: LTC2051HVIMS8#PBF

Connections:
+5V: C8.1, C10.1, C13.1, C14.1, C21.1, C22.1, C29.1, C30.1, C37.1, C38.1, C45.1, C46.1, L1.2, R7.1, U1.8, U2.8, U3.8, U4.8, U5.8
-5V: C4.1, C6.1, C9.2, C11.2, C16.1, C18.1, C24.1, C26.1, C32.1, C34.1, C40.1, C42.1, L2.2, R8.2, U1.4, U2.4, U3.4, U4.4, U5.4
Earth: J1.1, MH1.1, MH2.1, MH3.1, MH4.1, R1.1, R3.1
GND: C2.2, C3.2, J3.1, PS1.2, R1.2
GNDA: C4.2, C6.2, C8.2, C9.1, C10.2, C11.1, C13.2, C14.2, C16.2, C18.2, C21.2, C22.2, C24.2, C26.2, C29.2, C30.2, C32.2, C34.2, C37.2, C38.2, C40.2, C42.2, C45.2, C46.2, J6.1, J10.1, PS1.4, R3.2, R7.2, R8.1, U1.3, U1.5, U2.3, U2.5, U3.3, U3.5, U4.3, U4.5, U5.3, U5.5
unnamed: C1.1, R2.2
unnamed: C1.2, C5.1, R4.1, U1.2
unnamed: C2.1, C3.1, F1.2, PS1.1
unnamed: C5.2, R4.2, R5.1, U1.1
unnamed: C7.1, R5.2
unnamed: C12.1, J7.1, R6.1, U1.7
unnamed: C7.2, C12.2, R6.2, U1.6
unnamed: C15.1, R9.2
unnamed: C15.2, C17.1, R10.1, U2.2
unnamed: C17.2, R10.2, R11.1, U2.1
unnamed: C19.1, R11.2
unnamed: C19.2, C20.2, R12.2, U2.6
unnamed: C20.1, J11.1, R12.1, U2.7
unnamed: C23.1, R13.2
unnamed: C23.2, C25.1, R14.1, U3.2
unnamed: C25.2, R14.2, R15.1, U3.1
unnamed: C27.1, R15.2
unnamed: C27.2, C28.2, R16.2, U3.6
unnamed: C28.1, J9.1, R16.1, U3.7
unnamed: C31.1, R17.2
unnamed: C31.2, C33.1, R18.1, U4.2
unnamed: C33.2, R18.2, R19.1, U4.1
unnamed: C35.1, R19.2
unnamed: C35.2, C36.2, R20.2, U4.6
unnamed: C36.1, J13.1, R20.1, U4.7
unnamed: C39.1, R21.2
unnamed: C39.2, C41.1, R22.1, U5.2
unnamed: C41.2, R22.2, R23.1, U5.1
unnamed: C43.1, R23.2
unnamed: C43.2, C44.2, R24.2, U5.6
unnamed: C44.1, J15.1, R24.1, U5.7
unnamed: F1.1, J2.1
unnamed: J4.1, R2.1
unnamed: J5.1, R13.1
unnamed: J8.1, R9.1
unnamed: J12.1, R17.1
unnamed: J14.1, R21.1
unnamed: L1.1, PS1.5
unnamed: L2.1, PS1.3

Notes on the sheet:
Ch1 In
Ch1 Out
+24Vdc
GND
Earth
Ch2 In
Ch2 Out
Ch3 In
Ch3 Out
Common In
Common Out
Ch4 In
Ch4 Out
Ch5 Out
Ch5 In

Board: 6 copper layers, 74.5 x 68.0 mm, 98 parts (0 on the bottom side), 44 nets.

## Code that names these connections

File Code/STM32F427VIT6x Waveform Generator/STM32f427VIT6 Waveform Generator.ioc (part):

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Mcu.Name=STM32F427V(G-I)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F427VITx
PA0/WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.Mode=OTG/Dual_Role_Device
PA10.Signal=USB_OTG_FS_ID
PA11.Mode=OTG/Dual_Role_Device
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=OTG/Dual_Role_Device
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.Signal=COMP_DAC1_group
PA5.Signal=COMP_DAC2_group
PA6.Signal=S_TIM3_CH1
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=MAX485_PWR
PC0.Signal=GPIO_Output
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=TEMP_SENSE
PC2.Signal=ADCx_IN12
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=BTN3
PC6.Signal=GPXTI6
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=BTN2
PC7.Signal=GPXTI7
PC8.GPIOParameters=GPIO_Label
PC8.GPIO_Label=BTN1
PC8.Signal=GPXTI8
PD11.GPIOParameters=GPIO_Label
PD11.GPIO_Label=LED1
PD11.Signal=GPIO_Output
PD12.GPIOParameters=GPIO_Label
PD12.GPIO_Label=LED2
PD12.Signal=GPIO_Output
PD13.GPIOParameters=GPIO_Label
PD13.GPIO_Label=LED3
PD13.Signal=GPIO_Output
PD14.GPIOParameters=GPIO_Label
PD14.GPIO_Label=LED4
PD14.Signal=GPIO_Output
PD15.GPIOParameters=GPIO_Label
PD15.GPIO_Label=LED5
PD15.Signal=GPIO_Output
PD4.Mode=RTS_Only
PD4.Signal=USART2_RTS
PE9.Signal=S_TIM1_CH1
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

File Code/STM32F405RGT6 waveform generator/STM32F405RGT6 waveform generator.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.Mode=OTG/Dual_Role_Device
PA10.Signal=USB_OTG_FS_ID
PA11.Mode=OTG/Dual_Role_Device
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=OTG/Dual_Role_Device
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.Signal=COMP_DAC1_group
PA5.Signal=COMP_DAC2_group
PA6.Signal=S_TIM3_CH1
PA8.Signal=S_TIM1_CH1
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=LED3
PB13.Signal=GPIO_Output
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=LED2
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_PuPd,GPIO_Label
PB15.GPIO_Label=LED1
PB15.GPIO_PuPd=GPIO_NOPULL
PB15.Signal=GPIO_Output
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=MAX485_PWR
PC0.Signal=GPIO_Output
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=MAX485_DE
PC1.Signal=GPIO_Output
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=TEMP_SENSE
PC2.Signal=ADCx_IN12
PC6.GPIOParameters=GPIO_Label
PC6.GPIO_Label=Btn1_Input
PC6.Signal=GPXTI6
PC7.GPIOParameters=GPIO_PuPd,GPIO_Label
PC7.GPIO_Label=Btn2_Input
PC7.GPIO_PuPd=GPIO_NOPULL
PC7.Signal=GPXTI7
PC8.GPIOParameters=GPIO_PuPd,GPIO_Label
PC8.GPIO_Label=Btn3_Input
PC8.GPIO_PuPd=GPIO_NOPULL
PC8.Signal=GPXTI8
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=16000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_HSE
board=custom

## Commit log

2021-01-18 Initializing project
2021-01-18 Creating a sine wave
2021-01-18 Working on sine signal
2021-01-18 Benchmark, sine working
2021-01-18 Working sine
2021-01-18 Scaling sine
2021-01-18 Benchmark
2021-01-18 Benchmark, lunchtime
2021-01-18 Benchmark, setting sine frequency, and amplitude
2021-01-20 Check
2021-01-20 Benchmark, Perfect sine, scaled and shifted
2021-02-08 testing things
2021-02-09 USB test
2021-02-09 test
2021-02-09 Working on latest schematic
2021-02-09 Working on updating schematic
2021-02-10 PCB Update
2021-02-11 Working on schematic
2021-02-11 Updating schematic
2021-02-11 Making more updates
2021-02-11 Schematic mostly done
2021-02-12 Working on schematic footprints
2021-02-12 Almost done with component footprints
2021-02-12 Starting PCB layout
2021-02-12 update!
2021-02-15 Working
2021-02-15 New OP-amps and regulators
2021-02-15 Updating op-amps and powersupply
2021-02-16 Making updates to schematic
2021-02-16 Working on next chip
2021-02-16 Updating PCB with new micro
2021-02-16 Working on PCB design.
2021-02-16 Making progress with Updating the new schematic and footprints
2021-02-17 Working on PCB footprint placement
2021-02-17 Making progress with PCB layout
2021-02-17 Working on PCB layout
2021-02-17 Updating PCB layout
2021-02-17 Working on PCB design
2021-02-17 Making good progress
2021-02-17 Finalizing PCB layout
2021-02-17 Made good progress
2021-02-18 Working on progress
2021-02-18 Working on 2 CHannel DAC
2021-02-18 Working on a 2 channel dac
2021-02-18 Benchmark, USB and 2 Channel DAC
2021-02-18 Working on sorting out code
2021-02-18 Cleaning up work space
2021-02-19 Benchmark, Set up base project
2021-02-19 Working on PCB
2021-02-19 Making progress
2021-02-19 Routing power
2021-02-19 Working on PCB tracks
2021-02-19 Busy with ground planes
2021-02-19 Benchmark, looks if the majority of the work is complete
2021-02-22 Monday morning grind
2021-02-22 Almost finished with the PCB design
2021-02-22 Almost done
2021-02-22 Benchmark, final PCB layout
2021-02-22 Fixing small things
2021-02-22 Adding markers to indicator pin 1
2021-02-22 Logo Applied
2021-02-22 Stiching vias
2021-02-22 Working on BOM for JLCPCB
2021-02-22 working on BOM
2021-02-22 Benchmark, Done with BOM, time to place an order
2021-02-22 Benchmark CPL and BOM uploaded.
2021-02-23 Attempting to submit to JLCPCB
2021-02-23 Trying to order from JLCPCB
2021-02-23 Benchmark, Version 1 sent to JLCPCB for manufacture
2021-02-23 Updated files to MCU on PCBs
2021-02-23 UART test project now works
2021-02-23 Benchmark, Waveform Generator 2 channel with UART
2021-02-24 Working on Code
2021-02-25 Benchmark, Arbitrary Waveform Generator V1.1
2021-02-25 Revision 1.1
2021-02-26 Benchmark, UART, USB, 2 Channel output
2021-02-26 Tidying things up
2021-03-01 Bnechamark, UART to serial project
2021-03-01 upload
2021-03-01 Looks like I can enter the boot mode using the Nucleo-L476RG
2021-03-03 Working on things
2021-03-15 Working on Waveform Generator
2021-03-17 Making adjustments
2021-03-18 Working signal generation on the AWG board
2021-03-19 10khz channel 1
2021-03-19 Two working channels up to 11kHz
2021-03-19 20khz and 10khz output working with ns = 40
2021-03-19 Benchmark, AWG generates output signal
2021-03-19 Benchmark, Working AWG
2021-03-23 Making progress with the UART protocol. Able to send and receive messages.
2021-03-23 Benchmark, Making good progress with UART comms
2021-03-23 Independent frequency functions implemented
2021-03-23 Benchmark, scaling and frequency change
2021-03-23 End of Day, AWG working, busy with the Aether light code
2021-03-26 Working hard
2021-03-26 Aether Light Basic functioning
2021-04-06 Aether one working controller
2021-04-06 Benchmark, control and display, working on pot
2021-04-07 Working at MAX485
2021-04-07 Benchmark RS485 output with signal generation
2021-04-08 Benchmark, seems if RS485 is working
2021-04-08 Updating schematics and PCB
2021-04-28 save
2021-04-29 Looks like frequency and amplitude are working
2021-04-29 Benchmark, working really well
2021-05-26 Working, possible benchmark
2021-05-27 Benchmark, production V1.0
2021-06-03 Adjustments
2021-06-22 Changes made
2021-06-22 Moving files
2024-10-20 Organsing files
2024-10-20 More updates
2024-10-20 Reorganising files
2024-10-20 Clearing up codebase
2024-10-20 Additional updates
2024-11-08 Major reorgonisation and cleaning
2024-11-08 Refactoring and organising
2024-11-08 Cleaning up and reorganising
2024-11-08 correct the date
2024-11-08 Add standard libs
2024-11-08 move some declarations around
2024-11-08 remove main.h include
2024-11-08 including Ns in config
2024-11-09 renaming
2024-11-09 cleaning up
2025-01-04 Cleaning up project
2025-01-04 move file to correct location
2025-01-04 move image
2025-01-06 Update BSP
2025-01-06 updating bsp
2025-01-06 remove dead code
2025-01-06 update lib
2025-01-06 refactoring code
2025-01-06 refactoring and reorgansising
2025-01-06 refactor
2025-01-06 update state_machine with refactored code
2025-01-10 Update images, videos and pdf
2025-01-10 remove image
2025-01-11 oeganising images
2025-01-12 file type change
2025-01-22 update to folder structure
